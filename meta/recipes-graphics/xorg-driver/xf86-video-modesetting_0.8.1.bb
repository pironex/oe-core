require xorg-driver-video.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=5e53d3fcadb1c23d122ad63cb099a918"

DESCRIPTION = "X.Org X server -- modesetting display driver"

SRCREV = "07c5d9cb782fde2a073efdc437489d6c4b432d46"
SRC_URI = "git://anongit.freedesktop.org/xorg/driver/xf86-video-modesetting"

S = "${WORKDIR}/git"

